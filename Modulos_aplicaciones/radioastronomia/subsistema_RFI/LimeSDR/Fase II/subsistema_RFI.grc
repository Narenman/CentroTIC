<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>subsistemaRFI</value></param>
<param><key>author</key><value>Luis Miguel Diaz</value></param>
<param><key>description</key><value>Este modulo se encarga de adquirir las senales del espectro usando el LimeSDR</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>title</key><value>Adquisicion de datos del espectro</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frec_central</value></param>
<param><key>value</key><value>470e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ganancia</value></param>
<param><key>value</key><value>50</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nfft</value></param>
<param><key>value</key><value>1024</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>30e6</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/home/uis-e3t/Documentos/tmp_plataforma/espectro</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>nfft</value></param>
</block>
<block>
<key>limesdr_source</key>
<param><key>id</key><value>limesdr_source_0</value></param>
<param><key>allow_tcxo_dac</key><value>0</value></param>
<param><key>analog_bandw_ch0</key><value>samp_rate</value></param>
<param><key>calibr_bandw_ch0</key><value>samp_rate</value></param>
<param><key>digital_bandw_ch0</key><value>0</value></param>
<param><key>gain_dB_ch0</key><value>ganancia</value></param>
<param><key>analog_bandw_ch1</key><value>5e6</value></param>
<param><key>calibr_bandw_ch1</key><value>5e6</value></param>
<param><key>digital_bandw_ch1</key><value>0</value></param>
<param><key>gain_dB_ch1</key><value>30</value></param>
<param><key>channel_mode</key><value>0</value></param>
<param><key>serial</key><value>00090726074D311B</value></param>
<param><key>oversample</key><value>0</value></param>
<param><key>rf_freq</key><value>frec_central</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>dacVal</key><value>125</value></param>
</block>
<block>
<key>logpwrfft_x</key>
<param><key>id</key><value>logpwrfft_x_0</value></param>
<param><key>avg_alpha</key><value>0.3</value></param>
<param><key>average</key><value>True</value></param>
<param><key>fft_size</key><value>nfft</value></param>
<param><key>frame_rate</key><value>30</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ref_scale</key><value>2</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
</block>
<connection><source_block_id>limesdr_source_0</source_block_id><sink_block_id>logpwrfft_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>logpwrfft_x_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
